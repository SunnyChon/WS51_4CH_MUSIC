# Keil uVision project w51mid.uvproj, settings and files
target Target 1 (MCS-51)
  device: WS51F6240 WS51
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0-0x3FF) CLOCK(16000000)
  output: w51mid
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
